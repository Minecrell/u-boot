## arch/arm/mach-u8500/Kconfig
```kconfig
if ARCH_U8500

config SYS_SOC
	default "u8500"

choice
	prompt "U8500 board selection"

endchoice

endif
```
